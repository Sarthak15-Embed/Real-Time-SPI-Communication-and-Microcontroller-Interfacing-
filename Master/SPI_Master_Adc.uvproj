# Keil uVision project SPI_Master_Adc.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SPI_Master_Adc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s Arm_Adc.c Arm_Adc.h Arm_Lcd.c Arm_Lcd.h Arm_PLL.c Arm_PLL.h Arm_SPI.c Arm_SPI.h Delay.c Delay.h SPI_Master_Adc.c master.txt
